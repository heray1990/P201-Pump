# Keil uVision project P201-HDMCU.uvprojx, settings and files
target P201-HDMCU_Release (6150000::V6.15::ARMCLANG)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: P201-HDMCU +hex
  c flags: Optim=7 OneElfS=1 v6Lang=5 wLevel=4
  c include: ..\mcu\common;..\source;..\driver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../mcu/common/: interrupts_hc32l13x.c system_hc32l13x.c
  group source
    ../source/: main.c lcd_D61593A.c
  group driver
    ../driver/src/: ddl.c sysctrl.c lcd.c lpm.c gpio.c
software components: CMSIS:CORE 5.4.0
